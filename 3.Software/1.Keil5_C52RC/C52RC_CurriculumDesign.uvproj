# Keil uVision project C52RC_CurriculumDesign.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: C52RC_CurriculumDesign +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: STARTUP.A51
  group Source
    ./Source/: main.c
